options:
  parameters:
    author: abc
    generate_options: qt_gui
    id: LDPC_text
    output_language: python
    title: LDPC_text
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport threading\n\n####################################\n# PDU Bit + Channel + Noise Power Source\n####################################\nclass pdu_bit_h_noise(gr.basic_block):\n    \"\"\"\n    每隔 interval_s 秒发送 num_bits 比特，同时生成一个复高斯信道 h\n    并根据给定 SNR 和信号功率计算噪声功率\n    \"\"\"\n    def __init__(self, interval_s=1.0, num_bits=10, snr_db=10.0, signal_power=1.0, print_bits=True):\n        gr.basic_block.__init__(self,\n            name=\"pdu_bit_h_noise_source\",\n            in_sig=None, out_sig=None)\n\n        self.interval_s = float(interval_s)\n        self.num_bits = int(num_bits)\n        self.snr_db = float(snr_db)\n        self.signal_power = float(signal_power)\n        self.print_bits = bool(print_bits)\n\n        # 消息端口\n        self.message_port_register_out(pmt.intern(\"bits\"))\n        self.message_port_register_out(pmt.intern(\"h\"))\n        self.message_port_register_out(pmt.intern(\"noise_power\"))\n\n        # 开启线程\n        self.keep_running = True\n        self.thread = threading.Thread(target=self._run)\n        self.thread.daemon = True\n        self.thread.start()\n\n    def _run(self):\n        while self.keep_running:\n            # -------------------\n            # 生成比特\n            # -------------------\n            bits = np.random.randint(0, 2, self.num_bits).astype(np.uint8)\n            if self.print_bits:\n                print(\"#######################\")\n\n                print(\"[Bit Source] Bits:\", bits.tolist())\n\n            # ⚠️ 这里改为发送 PDU\n            bits_msg = pmt.init_u8vector(len(bits), bits)\n            bits_pdu = pmt.cons(pmt.PMT_NIL, bits_msg)  # 包装成 PDU\n            self.message_port_pub(pmt.intern(\"bits\"), bits_pdu)\n\n            # -------------------\n            # 生成复高斯信道 h\n            # -------------------\n            h = (np.random.randn() + 1j*np.random.randn()) / np.sqrt(2)\n            h_msg = pmt.from_complex(h)  # 直接发送复数 PMT\n            self.message_port_pub(pmt.intern(\"h\"), h_msg)\n\n            # -------------------\n            # 计算噪声功率\n            # -------------------\n            snr_linear = 10**(self.snr_db / 10)\n            noise_power = self.signal_power / snr_linear\n            noise_msg = pmt.from_double(float(noise_power))\n            self.message_port_pub(pmt.intern(\"noise_power\"), noise_msg)\n\n            time.sleep(self.interval_s)\n\n    def stop(self):\n        self.keep_running = False\n        self.thread.join()\n        return super().stop()\n\n\n\n\n\n\n\n\n"
    interval_s: '2'
    num_bits: '10'
    print_bits: 'True'
    signal_power: '2'
    snr_db: '10'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "# -*- coding: utf-8 -*-\nimport numpy as np\nimport pmt\nfrom gnuradio import gr\n\n####################################\n# PDU QPSK Modulator\n####################################\nclass qpsk_mod_pdu(gr.basic_block):\n    \"\"\"\n    PDU QPSK Mapper\n    输入：PDU（u8 类型，内容为0/1比特）\n    输出：PDU（complex64）\n    \"\"\"\n\n    def __init__(self, print_enable=False):\n        gr.basic_block.__init__(self,\n            name=\"PDU QPSK Modulator\",\n            in_sig=None,\n            out_sig=None)\n\n        self.print_enable = print_enable\n\n        # 设置端口\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n    def handle_pdu(self, msg):\n        meta = pmt.car(msg)\n        vec = pmt.cdr(msg)\n\n        # 转 numpy\n        bits = np.array(pmt.u8vector_elements(vec), dtype=np.uint8)\n\n        # 确保偶数个比特\n        if len(bits) % 2 != 0:\n            bits = bits[:-1]\n\n        # 拆成两比特一组\n        bit_pairs = bits.reshape((-1, 2))\n\n        # Gray 映射\n        mapping = {\n            (0,0): (1+1j),\n            (0,1): (1-1j),\n            (1,1): (-1-1j),\n            (1,0): (-1+1j),\n        }\n\n        syms = np.array([mapping[tuple(b)] for b in bit_pairs], dtype=np.complex64)\n\n        if self.print_enable:\n            print(f\"[QPSK Mod] Output symbols: {syms}\")\n\n        # 输出 PDU\n        out_vec = pmt.init_c32vector(len(syms), syms.tolist())\n        out_msg = pmt.cons(meta, out_vec)\n        self.message_port_pub(pmt.intern(\"out\"), out_msg)\n\n\n\n\n"
    print_enable: 'True'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      ####################################
      # QPSK Demod PDU
      ####################################
      class qpsk_demod_pdu(gr.basic_block):
          """
          QPSK Demod PDU
          输入：IQ PDU
          输出：bit 或 LLR PDU
          """
          def __init__(self, output_type='llr', verbose=False):
              gr.basic_block.__init__(self,
                  name="QPSK Demod PDU",
                  in_sig=None, out_sig=None)

              self.output_type = output_type.lower()
              self.verbose = verbose
              self.h = 1.0+0j
              self.noiseVar = 1.0

              # 消息端口
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("out"))

              self.message_port_register_in(pmt.intern("set_h"))
              self.set_msg_handler(pmt.intern("set_h"), self.handle_h)
              self.message_port_register_in(pmt.intern("set_noise"))
              self.set_msg_handler(pmt.intern("set_noise"), self.handle_noise)

          def handle_h(self, msg):
              self.h = pmt.to_complex(msg)
            
          def handle_noise(self, msg):
              self.noiseVar = float(pmt.to_python(msg))
            
          def handle_msg(self, msg):
              meta = pmt.car(msg)
              payload = pmt.cdr(msg)
              iq = np.array(pmt.c32vector_elements(payload), dtype=np.complex64)
              n = len(iq)

              # 信道补偿
              r = iq * np.conj(self.h)

              demod = np.zeros(2*n, dtype=np.float32)
              demod[0::2] = 2*np.real(r) / self.noiseVar
              demod[1::2] = 2*np.imag(r) / self.noiseVar

              if self.output_type == 'bit':
                  bits = (demod < 0).astype(np.uint8)
                  out_msg = pmt.cons(meta, pmt.init_u8vector(len(bits), bits))
              else:
                  out_msg = pmt.cons(meta, pmt.init_f32vector(len(demod), demod))

              # verbose 打印 PDU 内容
              if self.verbose:
                  payload = pmt.cdr(out_msg)
                  if self.output_type == 'bit':
                      data = np.array(pmt.u8vector_elements(payload), dtype=np.uint8)
                  else:
                      data = np.array(pmt.f32vector_elements(payload), dtype=np.float32)
                  print("[Demod] Output:", data.tolist())

              # 发送消息
              self.message_port_pub(pmt.intern("out"), out_msg)
    output_type: '''bit'''
    verbose: 'True'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading
      ####################################
      # Channel PDU (External h + noise)
      ####################################
      class channel_pdu_external(gr.basic_block):
          """
          PDU 信道：乘 h + 加噪声
          输入：
              - in: IQ PDU (c32vector)
              - set_h: 外部复数 h (PMT complex)
              - set_noise: 外部噪声功率 (float)
          输出：
              - out: IQ PDU
          """
          def __init__(self, verbose=False):
              gr.basic_block.__init__(self,
                  name="Channel PDU",
                  in_sig=None, out_sig=None)

              self.verbose = verbose
              self.h = 1.0+0j
              self.noiseVar = 0.0

              # 消息端口
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_in)

              self.message_port_register_in(pmt.intern("set_h"))
              self.set_msg_handler(pmt.intern("set_h"), self.handle_h)

              self.message_port_register_in(pmt.intern("set_noise"))
              self.set_msg_handler(pmt.intern("set_noise"), self.handle_noise)

              self.message_port_register_out(pmt.intern("out"))

          def handle_h(self, msg):
              self.h = pmt.to_complex(msg)  # msg 是 PMT complex
              if self.verbose:
                  print("[Channel] Set h =", self.h)

          def handle_noise(self, msg):
              self.noiseVar = float(pmt.to_python(msg))
              if self.verbose:
                  print("[Channel] Set noiseVar =", self.noiseVar)

          def handle_in(self, msg):
              meta = pmt.car(msg)
              payload = pmt.cdr(msg)
              iq = np.array(pmt.c32vector_elements(payload), dtype=np.complex64)
              n = len(iq)

              # 生成噪声
              if self.noiseVar > 0:
                  noise = np.sqrt(self.noiseVar/2)*(np.random.randn(n)+1j*np.random.randn(n))
              else:
                  noise = np.zeros(n, dtype=np.complex64)

              out_iq = iq*self.h + noise

              if self.verbose:
                  print("[Channel] output IQ:", out_iq)

              out_msg = pmt.cons(meta, pmt.init_c32vector(len(out_iq), out_iq))
              self.message_port_pub(pmt.intern("out"), out_msg)
    verbose: 'True'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: IQ
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: noise
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: h
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: IQ
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: h
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: noise
  states: {}

connections:
- [epy_block_0, bits, epy_block_1, in]
- [epy_block_0, h, virtual_sink_0_1, '0']
- [epy_block_0, noise_power, virtual_sink_0_0, '0']
- [epy_block_1, out, epy_block_3, in]
- [epy_block_3, out, virtual_sink_0, '0']
- [virtual_source_0, '0', epy_block_2, in]
- [virtual_source_0_0, '0', epy_block_2, set_h]
- [virtual_source_0_1, '0', epy_block_2, set_noise]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
