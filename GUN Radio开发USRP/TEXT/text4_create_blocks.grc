options:
  parameters:
    generate_options: qt_gui
    id: text4_create_blocks
    output_language: python
    title: create blocks
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: '-10000'
    step: '1000'
    stop: '10000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: frequency_shifter_block_0
  id: frequency_shifter_block
  parameters:
    frequency: frequency
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [frequency_shifter_block_0, '0', blocks_throttle2_0, '0']
- [low_pass_filter_0, '0', frequency_shifter_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
